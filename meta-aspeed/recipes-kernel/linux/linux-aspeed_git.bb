KBRANCH ?= "dev-ikvm-2"
LINUX_VERSION ?= "4.19.29"

SRCREV="6bf19530f1bde34a787efa6b745a560605cb8f8e"

require linux-aspeed.inc

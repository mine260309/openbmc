FILESEXTRAPATHS_prepend_romulus := "${THISDIR}/${PN}:"
SRC_URI += "file://romulus.cfg"
SRC_URI += "file://romulus-extent-ro.patch"
SRC_URI += "file://1.patch"
SRC_URI += "file://2.patch"
SRC_URI += "file://3.patch"
SRC_URI += "file://4.patch"
SRC_URI += "file://5.patch"
SRC_URI += "file://6.patch"

RDEPENDS_${PN}-inventory += " openpower-occ-control id-button phosphor-pid-control"
PACKAGES_remove += "${PN}-fan-control"
